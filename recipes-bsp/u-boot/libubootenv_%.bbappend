FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Note: fw_env.config is dynamically generated by rauc-setup-env.sh

do_install:append() {
    install -d ${D}${sysconfdir}
    # Create placeholder (will be overwritten by rauc-setup-env.sh)
    echo "# Placeholder - will be generated by rauc-setup-env.service" > ${D}${sysconfdir}/fw_env.config
}

RDEPENDS:${PN} += "rauc"